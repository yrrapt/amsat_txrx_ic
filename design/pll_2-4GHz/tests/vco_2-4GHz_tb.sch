** sch_path: design/pll_2-4GHz/tests/vco_2-4GHz_tb.sch
**.subckt vco_2-4GHz_tb
x1 VDD net1 Ip In REF Qp Qn 0 vco_2-4GHz
V1 REF 0 pulse(0 1.8 0ns 1ns 1ns 75ns 150ns)
Vdd VDD 0 1.8
I0 VDD net1 10u
**** begin user architecture code


*.option PARHIER=LOCAL RUNLVL=6 post MODMONTE=1 warn maxwarns=400
*.option ITL4=20000 ITL5=0
* .option sampling_method = SRS
* .option method=gear

*.lib xh018/xh018.lib tm
.include 'xh018_ng/xh018.lib'

*.option rshunt = 1.0e3
*.option keepopinfo = 1

.temp 30
.tran  0.1e-9 200e-6 uic
*.dc Vdd 1.8 1.8 0.25


**** end user architecture code
**.ends
.end
