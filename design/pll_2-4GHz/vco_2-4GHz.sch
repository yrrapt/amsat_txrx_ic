** sch_path: design/pll_2-4GHz/vco_2-4GHz.sch
**.subckt vco_2-4GHz Ip In Qp Qn BIAS REF VDD GND
*.opin Ip
*.opin In
*.opin Qp
*.opin Qn
*.ipin BIAS
*.ipin REF
*.iopin VDD
*.iopin GND
xpfd VDD down REF fb up GND phasefrequencydetector_ff w_n=0.5u l_n=0.18u w_p=1.5u l_p=0.18u
xdiv VDD fb Ip In net2 GND divider_256_4cml_64ff
xcp VDD up ctl BIAS down GND chargepump w_invp=3u l_invp=0.18u w_invn=1u l_invn=0.18u w_currn=1u
+ l_currn=4u w_currp=3u l_currp=4u m_curr=20 w_swn=1u l_swn=0.18u w_swp=3u l_swp=0.18u m_sw=4
C1 ctl GND 200p m=1
xvco VDD net1 Ip In Qp Qn GND vco_quad w_n=0.5u l_n=0.18u w_p= l_p=0.18u
C2 net1 GND 10p m=1
R1 net1 ctl 100k m=1
**.ends
.end
