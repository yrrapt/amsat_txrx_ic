** sch_path: design/chargepump/chargepump.sch
**.subckt chargepump BIAS OUT UP DOWN VDD GND
*.ipin BIAS
*.opin OUT
*.ipin UP
*.ipin DOWN
*.iopin VDD
*.iopin GND
XM1 UP_buf UP GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 UP_inv UP_buf GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 DOWN_inv DOWN GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 DOWN_buf DOWN_inv GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 UP_buf UP VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 UP_inv UP_buf VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 DOWN_inv DOWN VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 DOWN_buf DOWN_inv VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 net3 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM2 net3 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM14 BIAS BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM16 net1 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM10 net2 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM12 VDD DOWN_inv net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 OUT DOWN_buf net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 GND UP_inv net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM17 OUT UP_buf net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
**.ends
.end
