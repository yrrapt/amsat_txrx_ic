** sch_path: design/chargepump/tests/chargepump_tb.sch
**.subckt chargepump_tb
V1 DOWN 0 pulse(0 1.8 0ns 1ns 1ns 50ns 100ns)
Vdd VDD 0 1.8
I0 VDD net1 10u
C1 out 0 100p m=1
x1 VDD UP out net1 DOWN 0 chargepump w_invp=3u l_invp=0.18u w_invn=1u l_invn=0.18u w_currn=1u
+ l_currn=4u w_currp=3u l_currp=4u m_curr=20 w_swn=1u l_swn=0.18u w_swp=3u l_swp=0.18u m_sw=4
V2 UP 0 pulse(0 1.8 0ns 1ns 1ns 75ns 150ns)
**** begin user architecture code


*.option PARHIER=LOCAL RUNLVL=6 post MODMONTE=1 warn maxwarns=400
*.option ITL4=20000 ITL5=0
* .option sampling_method = SRS
* .option method=gear

*.lib xh018/xh018.lib tm
.include 'xh018_ng/xh018.lib'

*.option rshunt = 1.0e3
*.option keepopinfo = 1

.temp 30
.tran  1e-9 10e-6 uic
*.dc Vdd 1.8 1.8 0.25


**** end user architecture code
**.ends

* expanding   symbol:  chargepump/chargepump.sym # of pins=6
** sym_path: design/chargepump/chargepump.sym
** sch_path: design/chargepump/chargepump.sch
.subckt chargepump VDD UP OUT BIAS DOWN GND  w_invp=3u l_invp=0.18u w_invn=1u l_invn=0.18u
+ w_currn=1u l_currn=4u w_currp=3u l_currp=4u m_curr=20 w_swn=1u l_swn=0.18u w_swp=3u l_swp=0.18u m_sw=4
*.ipin BIAS
*.opin OUT
*.ipin UP
*.ipin DOWN
*.iopin VDD
*.iopin GND
XM1 UP_buf UP GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 UP_inv UP_buf GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 DOWN_inv DOWN GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 DOWN_buf DOWN_inv GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 UP_buf UP VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 UP_inv UP_buf VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 DOWN_inv DOWN VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 DOWN_buf DOWN_inv VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 net3 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM2 net3 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM14 BIAS BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM16 net1 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM10 net2 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM12 VDD DOWN_inv net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 OUT DOWN_buf net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 GND UP_inv net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM17 OUT UP_buf net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
