** sch_path: design/phasefrequencydetector_ff/tests/phasefrequencydetector_ff_tb.sch
**.subckt phasefrequencydetector_ff_tb
V1 fb 0 pulse(0 1.8 delay 1ns 1ns {0.5*period} period)
Vdd VDD 0 1.8
C1 down 0 0.1p m=1
V2 ref 0 pulse(0 1.8 0ns 1ns 1ns 50ns 100ns)
x1 VDD down ref fb up 0 phasefrequencydetector_ff w_n=0.5u l_n=0.18u w_p=1.5u l_p=0.18u
C2 up 0 0.1p m=1
G1 0 out up down 1e-6
C3 out 0 1p m=1
x2 VDD up net1 net2 down 0 chargepump w_invp=3u l_invp=0.18u w_invn=1u l_invn=0.18u w_currn=1u
+ l_currn=4u w_currp=3u l_currp=4u m_curr=20 w_swn=1u l_swn=0.18u w_swp=3u l_swp=0.18u m_sw=4
I0 VDD net2 10u
C4 net1 0 100p m=1
R1 out_cp net1 100k m=1
C5 out_cp 0 10p m=1
**** begin user architecture code


*.option PARHIER=LOCAL RUNLVL=6 post MODMONTE=1 warn maxwarns=400
*.option ITL4=20000 ITL5=0
* .option sampling_method = SRS
* .option method=gear

*.lib xh018/xh018.lib tm
.include '/home/tom/.xschem/simulations/xh018_ng/xh018.lib'

.param delay=0
.param period=50ns

*.option rshunt = 1.0e3
*.option keepopinfo = 1

.ic v(out_cp)=0.9

.temp 30
.tran  1e-9 10e-6 uic
*.dc Vdd 1.8 1.8 0.25


**** end user architecture code
**.ends

* expanding   symbol:  phasefrequencydetector_ff/phasefrequencydetector_ff.sym # of pins=6
** sym_path: design/phasefrequencydetector_ff/phasefrequencydetector_ff.sym
** sch_path: design/phasefrequencydetector_ff/phasefrequencydetector_ff.sch
.subckt phasefrequencydetector_ff VDD DOWN REF FB UP GND  w_n=0.5u l_n=0.18u w_p=1.5u l_p=0.18u
*.ipin FB
*.opin DOWN
*.iopin VDD
*.iopin GND
*.opin UP
*.ipin REF
XMtrangatepu net2 net4 VDD VDD pe w=w_p l=l_p m=1
XMtrangatenub net5 net4 GND GND ne w=w_n l=l_n m=1
XMinvpuc DOWN net1 VDD VDD pe w=w_p l=l_p m=1
XMinvnuc DOWN net1 GND GND ne w=w_n l=l_n m=1
XMinvpub net4 net3 VDD VDD pe w=w_p l=l_p m=1
XMinvnub net4 net3 GND GND ne w=w_n l=l_n m=1
XMinvpua net3 FB VDD VDD pe w=w_p l=l_p m=1
XMinvnua net3 FB GND GND ne w=w_n l=l_n m=1
XMtrangatepd net8 net6 VDD VDD pe w=w_p l=l_p m=1
XMtrangatendb net10 net6 GND GND ne w=w_n l=l_n m=1
XMinvpdc UP net7 VDD VDD pe w=w_p l=l_p m=1
XMinvndc UP net7 GND GND ne w=w_n l=l_n m=1
XMinvpdb net6 net9 VDD VDD pe w=w_p l=l_p m=1
XMinvndb net6 net9 GND GND ne w=w_n l=l_n m=1
XMinvpda net9 REF VDD VDD pe w=w_p l=l_p m=1
XMinvnda net9 REF GND GND ne w=w_n l=l_n m=1
XMtrangatepu1 net1 net5 VDD VDD pe w=w_p l=l_p m=1
XMtrangatenub2 net11 net5 GND GND ne w=w_n l=l_n m=1
XMtrangatenua3 net1 net6 net11 GND ne w=w_n l=l_n m=1
XMtrangatepd4 net7 net10 VDD VDD pe w=w_p l=l_p m=1
XMtrangatendb5 net12 net10 GND GND ne w=w_n l=l_n m=1
XMtrangatenda6 net7 net4 net12 GND ne w=w_n l=l_n m=1
XMtrangatepd1 net10 net4 net8 VDD pe w=w_p l=l_p m=1
XMtrangatepu2 net5 net6 net2 VDD pe w=w_p l=l_p m=1
.ends


* expanding   symbol:  chargepump/chargepump.sym # of pins=6
** sym_path: design/chargepump/chargepump.sym
** sch_path: design/chargepump/chargepump.sch
.subckt chargepump VDD UP OUT BIAS DOWN GND  w_invp=3u l_invp=0.18u w_invn=1u l_invn=0.18u
+ w_currn=1u l_currn=4u w_currp=3u l_currp=4u m_curr=20 w_swn=1u l_swn=0.18u w_swp=3u l_swp=0.18u m_sw=4
*.ipin BIAS
*.opin OUT
*.ipin UP
*.ipin DOWN
*.iopin VDD
*.iopin GND
XM1 UP_buf UP GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 UP_inv UP_buf GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 DOWN_inv DOWN GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 DOWN_buf DOWN_inv GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 UP_buf UP VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 UP_inv UP_buf VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 DOWN_inv DOWN VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 DOWN_buf DOWN_inv VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM11 net3 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM2 net3 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM14 BIAS BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM16 net1 BIAS GND GND sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad=[expr 1 *0.29] as=[expr 1 *0.29]
+ pd=[expr 2*(1 + 0.29)] ps=[expr 2*(1 + 0.29)] nrd=[expr 0.29/1 ] nrs=[expr 0.29/1 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XM10 net2 net3 VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=3 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XM12 VDD DOWN_inv net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM13 OUT DOWN_buf net1 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM15 GND UP_inv net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM17 OUT UP_buf net2 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
