** sch_path: design/bandgap_opamp_threestage/bandgap_opamp_threestage.sch
**.subckt bandgap_opamp_threestage inp inn bias out vdd gnd
*.ipin inp
*.ipin inn
*.ipin bias
*.opin out
*.iopin vdd
*.iopin gnd
XMmpdiff net9 net2 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=8 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=32 m=32
XMmpr net2 net2 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=8 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=8 m=8
XMmnr bias bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XMmnb net2 bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XMtrioden net11 net5 gnd gnd sky130_fd_pr__nfet_01v8_lvt L=8 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2
+ *0.29] pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0
+ mult=1 m=1
XMmpa net10 net2 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=8 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=4 m=4
XMcpdiff net1 net8 net9 vdd sky130_fd_pr__pfet_01v8_lvt L=0.5 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=32 m=32
XMmna net8 bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=2
+ m=2
XMtriodep net12 net8 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=4 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
XMcpa net5 net8 net10 vdd sky130_fd_pr__pfet_01v8_lvt L=0.5 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=4 m=4
XMcasba net5 net5 net11 gnd sky130_fd_pr__nfet_01v8_lvt L=1 W=5 nf=1 ad=[expr 5 *0.29] as=[expr 5
+ *0.29] pd=[expr 2*(5 + 0.29)] ps=[expr 2*(5 + 0.29)] nrd=[expr 0.29/5 ] nrs=[expr 0.29/5 ] sa=0 sb=0 sd=0
+ mult=8 m=8
.save v(net3)
XMcasn net7 net5 net4 gnd sky130_fd_pr__nfet_01v8_lvt L=1 W=5 nf=1 ad=[expr 5 *0.29] as=[expr 5
+ *0.29] pd=[expr 2*(5 + 0.29)] ps=[expr 2*(5 + 0.29)] nrd=[expr 0.29/5 ] nrs=[expr 0.29/5 ] sa=0 sb=0 sd=0
+ mult=8 m=8
XMcasp net6 net5 net3 gnd sky130_fd_pr__nfet_01v8_lvt L=1 W=5 nf=1 ad=[expr 5 *0.29] as=[expr 5
+ *0.29] pd=[expr 2*(5 + 0.29)] ps=[expr 2*(5 + 0.29)] nrd=[expr 0.29/5 ] nrs=[expr 0.29/5 ] sa=0 sb=0 sd=0
+ mult=8 m=8
XMloadmp net13 net6 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XMloadmn net14 net6 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XMloadcn net7 net8 net14 vdd sky130_fd_pr__pfet_01v8_lvt L=0.5 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=10 m=10
XMloadcp net6 net8 net13 vdd sky130_fd_pr__pfet_01v8_lvt L=0.5 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=10 m=10
XMmfn net4 bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=8
+ m=8
XMmfp net3 bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=8
+ m=8
XMdiffn net4 inp net1 net1 sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=64 m=64
XMdiffp net3 inn net1 net1 sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=64 m=64
.save v(net5)
.save v(net1)
.save v(net8)
.save v(net2)
.save v(net14)
.save v(net6)
XMcpdiff1 net8 net8 net12 vdd sky130_fd_pr__pfet_01v8_lvt L=0.5 W=5 nf=1 ad='W * 0.29' as='W * 0.29'
+ pd='2 * (W + 0.29)' ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=2 m=2
.save v(net4)
XMmnc out bias gnd gnd sky130_fd_pr__nfet_01v8_lvt L=4 W=2 nf=1 ad=[expr 2 *0.29] as=[expr 2 *0.29]
+ pd=[expr 2*(2 + 0.29)] ps=[expr 2*(2 + 0.29)] nrd=[expr 0.29/2 ] nrs=[expr 0.29/2 ] sa=0 sb=0 sd=0 mult=16
+ m=16
XMgain out net7 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='W * 0.29' as='W * 0.29' pd='2 * (W + 0.29)'
+ ps='2 * (W + 0.29)' nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=4 m=4
XC1 out net14 sky130_fd_pr__cap_mim_m3_1 W=30 L=30 MF=16 m=16
**.ends
.end
