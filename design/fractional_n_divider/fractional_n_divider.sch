v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
C {ipin.sym} -90 -60 0 0 {name=p1 lab=rst}
C {ipin.sym} -90 -20 0 0 {name=p2 lab=input_frequency}
C {opin.sym} 60 -60 0 0 {name=p3 lab=output_frequency}
C {ipin.sym} -90 20 0 0 {name=p4 lab=data_in[25:0]}
C {ipin.sym} -90 60 0 0 {name=p5 lab=dither_select[1:0]}
C {opin.sym} 60 60 0 0 {name=p6 lab=dither_output}
